SUMMARY = "Xorg panel rotation and matching touch transform for AZ0x boards"
DESCRIPTION = "Drops an xorg.conf.d snippet that rotates the display at X \
startup and applies the matching touchscreen transformation matrix. \
\
The az0x panels are mounted rotated: each board's dtb carries a `rotation` \
property in its panel node (0x10e = 270 degrees, 0x5a = 90). The kernel turns \
that into a DRM panel-orientation property, which Wayland compositors honour \
automatically - Weston comes up correctly oriented with no configuration. \
Xorg's modesetting driver ignores it entirely, so X needs to be told. \
\
Rotation MUST be set at server startup, not at runtime. Applying \
`xrandr --rotate` to a live connector wedges the RK3288 display pipeline: \
the MIPI-DSI command FIFO fails mid-modeset and the VOP never recovers \
(flip_done timed out / commit wait timed out), needing a reboot. Observed on \
jp11. Hence a config file rather than a session script. \
\
The touch matrix must match the rotation or taps land in the wrong place. \
libinput is used rather than evdev because evdev has no TransformationMatrix \
option."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit features_check
REQUIRED_DISTRO_FEATURES = "x11"

# Board facts, set per machine in conf/machine/*.conf. Empty rotation means
# "not known for this board" and nothing is installed.
AZ0X_XORG_ROTATE ?= ""
AZ0X_XORG_TOUCH_MATRIX ?= ""
AZ0X_XORG_OUTPUT ?= "DSI-1"

S = "${WORKDIR}"
PACKAGE_ARCH = "${MACHINE_ARCH}"

do_configure[noexec] = "1"
do_compile[noexec] = "1"

do_install() {
    if [ -z "${AZ0X_XORG_ROTATE}" ]; then
        # Board rotation unknown or not uniform across its dtbs - ship nothing
        # rather than guess and hand someone a sideways screen.
        exit 0
    fi

    install -d ${D}${sysconfdir}/X11/xorg.conf.d
    cat > ${D}${sysconfdir}/X11/xorg.conf.d/10-panel-rotation.conf <<XORGEOF
# Generated by az0x-panel-rotation for MACHINE=${MACHINE}.
# Panel is mounted rotated; see the rotation property in this board's dtb.

Section "Device"
    Identifier "RK3288 VOP"
    Driver "modesetting"
    Option "monitor-${AZ0X_XORG_OUTPUT}" "${AZ0X_XORG_OUTPUT}"
EndSection

Section "Monitor"
    Identifier "${AZ0X_XORG_OUTPUT}"
    Option "Rotate" "${AZ0X_XORG_ROTATE}"
EndSection

Section "InputClass"
    Identifier "AZ0x touchscreen rotation"
    MatchIsTouchscreen "on"
    Driver "libinput"
    Option "TransformationMatrix" "${AZ0X_XORG_TOUCH_MATRIX}"
EndSection
XORGEOF
}

FILES:${PN} = "${sysconfdir}/X11/xorg.conf.d"

# The libinput input driver, not evdev - see DESCRIPTION.
RDEPENDS:${PN} = "xf86-input-libinput"

ALLOW_EMPTY:${PN} = "1"
